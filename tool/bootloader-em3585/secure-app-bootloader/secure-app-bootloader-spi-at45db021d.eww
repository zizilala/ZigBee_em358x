<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\secure-app-bootloader-spi-at45db021d.ewp</path>
  </project>
  <batchBuild/>
</workspace>


