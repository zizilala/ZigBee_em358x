<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\app-bootloader-spi-m45pe20.ewp</path>
  </project>
  <batchBuild/>
</workspace>


