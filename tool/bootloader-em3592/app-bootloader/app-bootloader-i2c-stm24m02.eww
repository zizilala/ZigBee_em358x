<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\app-bootloader-i2c-stm24m02.ewp</path>
  </project>
  <batchBuild/>
</workspace>


